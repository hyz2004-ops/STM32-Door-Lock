# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\Library\inc;..\Core;..\hardware;..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../Core/: startup_stm32f40_41xxx.s
  group user
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
  group library
    ../Library/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group hardware
    ../Hardware/: delay.c usart.c led.c beep.c keypad.c board_key.c oled.c esp8266.c mqtt.c as608.c lock.c rc522.c w25qxx.c storage.c scheduler.c rtc.h rtc.c
